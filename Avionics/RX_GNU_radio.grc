options:
  parameters:
    generate_options: qt_gui
    id: RX_GNU_radio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bit_Slip
  id: variable_qtgui_range
  parameters:
    label: Bit_Slip
    rangeType: int
    start: '0'
    step: '1'
    stop: '7'
    value: '0'
  states: {}
- name: Freq_shift
  id: variable_qtgui_range
  parameters:
    label: Freq_shift
    start: '-20000'
    step: '50'
    stop: '20000'
    value: '0'
  states: {}
- name: Loop_Band_width
  id: variable_qtgui_range
  parameters:
    label: Loop_Band_width
    start: '0'
    step: '.001'
    stop: '.1'
    value: '.01'
  states: {}
- name: SampleRate
  id: variable
  parameters:
    value: '1_000_000'
  states: {}
- name: constellation_obj
  id: variable_constellation_rect
  parameters:
    const_points: '[1+1j, -1+1j, -1-1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(32, 32, 1.0, 0.35, 11*32)
  states: {}
- name: variable_config_0
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: real
    value: '0'
    writeback: None
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jacob/Code/IREC_2026/Avionics/rocket_flight_raw.ts
    type: byte
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: Bit_Slip
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_obj
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '01000111'
    tagname: 47 40
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: Loop_Band_width
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '0'
    loop_bw: Loop_Band_width
    max_dev: '1.5'
    osps: '1'
    sps: '4'
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '.01'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '4'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '65536'
    filter_source: '''Auto'''
    frequency: 915000000 + Freq_shift
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: '15'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: SampleRate
    type: fc32
    uri: ip:192.168.4.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '500000'
    decim: '1'
    gain: '1'
    samp_rate: SampleRate
    type: fir_filter_ccf
    width: '100000'
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1316'
    port: '10001'
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: SampleRate
    type: complex
  states: {}

connections:
- [blocks_not_xx_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', network_udp_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_not_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_skiphead_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [low_pass_filter_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
